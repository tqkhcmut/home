# Keil uVision project home.uvproj, settings and files
target STM32F100RB (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: home
  c flags: Optim=1 wLevel=2
  c include: ..\..\home;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User Code
    ../delay/: delay.c
    ../usart/: usart.c
    ../: spi.c queue.cpp main.cpp stm32f10x_it.cpp converter.cpp assistant.cpp
    ../ENC28J60/: client.cpp enc28j60.c ip_arp_udp_tcp.c
  group Libraries
    ./: startup_stm32f10x_md_vl.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Utilities
    ../Utilities/: STM32vldiscovery.c
